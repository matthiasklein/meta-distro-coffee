
# additional mount points
dirs755 += "/sde /sdi"
