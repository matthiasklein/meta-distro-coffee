DEPENDS:remove = "qtdeclarative"

