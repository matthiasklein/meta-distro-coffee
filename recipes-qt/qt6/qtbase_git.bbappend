PACKAGECONFIG:class-native:remove = "gui widgets"
PACKAGECONFIG:class-nativesdk:remove = "gui widgets"
PACKAGECONFIG:remove = "gui widgets"

